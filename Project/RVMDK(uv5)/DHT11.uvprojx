# Keil uVision project DHT11.uvprojx, settings and files
target dht11 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DHT11 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\..\STM32F1_Library_ILI9341_LCD\USER\drive_LCD_ili9341;..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\USER\dht11;..\..\USER\systick;..\..\USER\usart;..\..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c
  group USER
    ../../USER/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../USER/systick/: bsp_systick.c
    ../../USER/usart/: bsp_usart.c
    ../../USER/dht11/: bsp_dht11.c
    ../../USER/drive_LCD_ili9341/: drive_LCD_ili9341.c ASCII.h
  group DOC
    ../../DOC/: readme.txt
